# Keil uVision project ElectricFeel.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RASDemo
  c flags: Optim=1
  c include: ..\..\StellarisWare;..\..\RASLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./: Startup.s Main.c RASDemo.h
  group External
    C:/Users/Michelle Chou/Documents/GitHub/Rasware2012/StellarisWare/driverlib/rvmdk/: driverlib.lib
    C:/Users/Michelle Chou/Documents/GitHub/Rasware2012/RASLib/Debug/: raslib.lib
    C:/Users/Michelle Chou/Documents/GitHub/Rasware2012/StellarisWare/utils/: uartstdio.c
  group Source
    ./: EncoderDemo.c IRSensorDemo.c LineSensorDemo.c MotorDemo.c ServoDemo.c UARTDemo.c
